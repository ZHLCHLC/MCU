# Keil uVision project bishe.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: bishe +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\user
  group bsp
    ../bsp/: air.c air.h guangzhao.c guangzhao.h timer.c timer.h uart.c uart.h RS485.c RS485.h adc.c adc.h
  group user
    ../user/: main.c pbdata.c pbdata.h
